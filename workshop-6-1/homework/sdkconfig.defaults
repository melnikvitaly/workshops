## workshop-6-1/homework/sdkconfig.defaults
```kconfig
CONFIG_FREERTOS_HZ=1000
CONFIG_FREERTOS_USE_TRACE_FACILITY=y
CONFIG_ESPTOOLPY_FLASHSIZE_4MB=y
```
